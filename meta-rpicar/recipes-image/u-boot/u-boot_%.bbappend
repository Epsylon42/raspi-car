FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://uboot.cfg"

