FILESEXTRAPATHS:prepend:df-rpicar-ota := "${THISDIR}/files-ota:"
WIC_CREATE_EXTRA_ARGS:df-rpicar-ota = "--no-fstab-update"
